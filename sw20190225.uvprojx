# Keil uVision project sw20190225.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: JEC_AQMV-F4E_V103 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1,__FPU_USED = 1
  c include: .\STM32F4_FWLIB\inc;.\STM32F4_FWLIB\src;.\Startup_config;.\Objects;.\Listings;.\STM32F4_FWLIB;.\add
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./Startup_config/: startup_stm32f40_41xxx.s
    ./add/: main.c stm32f4xx_it.c init.c time.c uart.c
  group STM32F4_FWLIB
    ./STM32F4_FWLIB/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_flash.c stm32f4xx_iwdg.c
  group Startup_config
    ./Startup_config/: system_stm32f4xx.c
  group add
    ./add/: bsp_uart.c gprs_dev.c ec20.c stmflash.c mqtt_ec.c sys.c mymodbus.c IWDG.c
